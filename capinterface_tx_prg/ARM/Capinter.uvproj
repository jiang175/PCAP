# Keil uVision project Capinter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Capinter +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA BOARD_NRF6310
  c misc: --c99
  c include: C:\Keil\ARM\Device\Nordic\nrf51422\Include\s210;C:\Keil\ARM\Device\Nordic\nrf51422\Include\sd_common;C:\Keil\ARM\Device\Nordic\nrf51422\Include\app_common;..\nrf51422\Board\nrf6310\spi_master_example;C:\Keil\ARM\Device\Nordic\nrf51422\Include
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x34000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group Main
    ../: PCAPint_main.c
  group core
    ./: arm_startup_nrf51.s
    ../nrf51422/Source/templates/: system_nrf51422.c
  group New Group
    ../nrf51422/Source/spi_master/: spi_master.c
    ../nrf51422/Source/nrf_delay/: nrf_delay.c
